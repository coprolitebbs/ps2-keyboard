File: hardware/kicad_project/Butts 2.kicad_sch (KiCad schematic)
At the start: 17 parts

Commit message: Iteration 2
Parts:
- gave numbers to parts that had none: 17
